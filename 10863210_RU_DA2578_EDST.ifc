Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-07-06T11:55:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 06 11:55:10 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{E4FEC65F-B8A1-4BC5-BF73-D20C58EAB8AF}\ifc * Database version: 5507 * Database creation date: Tue Jul 06 11:55:09 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 06 11:55:09 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 06 11:55:09 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 28257855_RU_10863210_DA2578_EDST, 10863210_RU_DA2578_EDST:28257855_RU_10863210_DA2578_EDST:207522
In: Level 1
Type - Material: Aluminum, z_Miele_Design_CLST, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel, z_Miele_Design_Glass
Pset_BuildingElementProxyCommon - Reference: 28257855_RU_10863210_DA2578_EDST
Pset_ManufacturerTypeInformation - Manufacturer: Miele
